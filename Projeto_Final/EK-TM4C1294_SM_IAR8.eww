<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Projects\asm_example\asm_example.ewp</path>
    </project>
    <batchBuild />
</workspace>
